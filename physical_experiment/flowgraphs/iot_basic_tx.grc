options:
  parameters:
    description: Basic TX for IoT Experiment
    generate_options: qt_gui
    id: iot_basic_tx
    output_language: python
    title: IoT Basic TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2475000000'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    pass_tags: 'True'
    timeout: '100'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/iot_tx_output.bin
    type: byte
  states: {}

connections:
- [zeromq_pull_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
