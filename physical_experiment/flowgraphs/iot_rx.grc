options:
  parameters:
    author: IoT Replay Defense
    description: 'RX: HackRF -> GFSK Demod -> ZMQ'
    generate_options: qt_gui
    id: iot_rx
    output_language: python
    title: IoT Replay Defense RX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2475000000'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '101562'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: freq
    comment: HackRF RX
    gain: '24'
    samp_rate: samp_rate
    type: fc32
    vga: '20'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Bandpass
    cutoff_freq: baud*2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: baud*0.5
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM Demod
    gain: samp_rate/(2*3.14159*deviation)
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Timing Recovery
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_rate/baud
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: To Bits
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: To Python
    pass_tags: 'True'
    timeout: '100'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"RX Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Demod
    name: '"Demodulated"'
    size: '1024'
    srate: baud
    type: float
  states: {}

connections:
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
