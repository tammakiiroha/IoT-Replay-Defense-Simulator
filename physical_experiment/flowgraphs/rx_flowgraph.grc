options:
  parameters:
    author: IoT Replay Defense
    description: RX Flowgraph for IoT Replay Attack Defense Experiment
    generate_options: qt_gui
    id: rx_flowgraph
    output_language: python
    title: IoT Replay Defense RX
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2475e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: lna_gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: vga_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: frequency
    comment: HackRF RX
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Bandpass filter
    cutoff_freq: baud_rate*2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: baud_rate*0.5
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: FM demodulation for FSK
    gain: samp_rate/(2*3.14159*101562)
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    comment: Symbol timing recovery
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_rate/baud_rate
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters:
    comment: Convert to bits
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10100101101001011010010110100101'
    comment: Preamble detection (0xA5A5A5A5)
    tagname: packet_start
    threshold: '0'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: Pack bits to bytes
    k: '8'
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: Send frames to Python script
    pass_tags: 'True'
    timeout: '100'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    name: '"RX Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Demodulated Signal"'
    size: '1024'
    srate: baud_rate
    type: float
  states: {}

connections:
- [soapy_hackrf_source_0, '0', low_pass_filter_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', zeromq_push_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
