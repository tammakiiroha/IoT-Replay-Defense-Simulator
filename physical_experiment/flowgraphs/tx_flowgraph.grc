options:
  parameters:
    author: IoT Replay Defense
    description: TX Flowgraph for IoT Replay Attack Defense Experiment
    generate_options: qt_gui
    id: tx_flowgraph
    output_language: python
    title: IoT Replay Defense TX
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 2475e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5555
    comment: Receives frames from Python script
    pass_tags: 'True'
    timeout: '100'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: NRZ encoding
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1, 1]'
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Gaussian filter for GFSK
    interp: int(samp_rate/baud_rate)
    taps: firdes.gaussian(1.0, int(samp_rate/baud_rate), 0.5, 4*int(samp_rate/baud_rate))
    type: fff
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: FSK modulation, 5kHz deviation
    sensitivity: 2*3.14159*101562/samp_rate
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: frequency
    comment: HackRF TX
    samp_rate: samp_rate
    type: fc32
    vga: tx_gain
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [zeromq_pull_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', soapy_hackrf_sink_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
